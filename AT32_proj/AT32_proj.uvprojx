# Keil uVision project AT32_proj.uvprojx, settings and files
target AT32_petabrew (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F413RCT7 ArteryTek
  pack: ArteryTek.AT32F413_DFP.2.0.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AT32_proj +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F413Rx_HD,USE_STDPERIPH_DRIVER,AT_START_F413_V1_0
  c include: ..\inc;..\src;..\AT32_proj;..\makefile\src;..\makefile\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Drivers/CMSIS
    ../src/: system_at32f4xx.c startup_at32f413rx_hd.s
  group User
    ../src/: at32f4xx_it.c main.c
    ../makefile/src/: at32_delay.c configuration.c global.c
    ../makefile/inc/: at32_delay.h configuration.h global.h
  group Drivers/AT32Periph
    ../src/: at32f4xx_exti.c at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_gpio_ex.c at32f4xx_i2c.c at32f4xx_rcc.c at32f4xx_spi.c at32f4xx_usart.c misc.c at32f4xx_adc.c at32f4xx_dma.c at32f4xx_tim.c
